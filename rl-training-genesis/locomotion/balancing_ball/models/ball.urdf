Commit message: Update suze

File: rl-training-genesis/locomotion/balancing_ball/models/ball.urdf (robot description, URDF)
Before this commit: robot balance_ball, 2 links, 1 joints
Links:
- removed link base_link
Joints:
- removed joint base_to_ball
